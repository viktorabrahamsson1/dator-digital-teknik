<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Lab3_1\Lab3_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Lab3_2\Lab3_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


